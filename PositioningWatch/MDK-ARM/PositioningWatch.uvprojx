# Keil uVision project PositioningWatch.uvprojx, settings and files
target PositioningWatch (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F412RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: PositioningWatch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F412Rx,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550 --diag_suppress=188
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\HARDWARE\LCD;..\Drivers\GUI;..\Drivers\GUI\lvgl;..\Drivers\GUI\lvgl_driver;..\Drivers\HARDWARE\KEY;..\Drivers\HARDWARE\MPU6050;..\Drivers\HARDWARE\MPU6050\eMPL;..\Drivers\HARDWARE\KALMAN_FILTER;..\Drivers\HARDWARE\FUNCTION;..\Drivers\GUI_APP;..\Drivers\CMSIS\DSP\Include
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32f412rx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c fsmc.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HARDWARE
    ../Drivers/HARDWARE/LCD/: lcd.c
    ../Drivers/HARDWARE/KEY/: key.c
    ../Drivers/HARDWARE/MPU6050/: mpu6050.c
    ../Drivers/HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Drivers/HARDWARE/KALMAN_FILTER/: kalman_filter.c
    ../Drivers/HARDWARE/FUNCTION/: other_function.c
  group GUI
    ../Drivers/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Drivers/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Drivers/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Drivers/GUI/lvgl/src/extra/: lv_extra.c
    ../Drivers/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Drivers/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Drivers/GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Drivers/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Drivers/GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Drivers/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Drivers/GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../Drivers/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Drivers/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Drivers/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Drivers/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Drivers/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Drivers/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Drivers/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Drivers/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Drivers/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Drivers/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Drivers/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Drivers/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Drivers/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Drivers/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Drivers/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Drivers/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Drivers/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Drivers/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Drivers/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Drivers/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Drivers/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Drivers/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Drivers/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Drivers/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Drivers/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Drivers/GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
    ../Drivers/GUI/lvgl/demos/widgets/: lv_demo_widgets.c
    ../Drivers/GUI/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../Drivers/GUI/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../Drivers/GUI/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../Drivers/GUI/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group GUI_APP
    ../Drivers/GUI_APP/: my_gui.c my_font.c
  group DSB_LIB
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.5.0
